# IAR project STM32F103C8T dev board.ewp, settings and files
configuration STM32F103C8T dev board (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../Core/Inc; C:\OneDrive\ST STM32\STM32F103C8T_DevBoard\stm32-tm1637; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F103C8T dev board.hex
  ILINK.IlinkOutputFile: STM32F103C8T dev board.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../stm32-tm1637/: stm32_tm1637.c stm32_tm1637.h
  group Application/User/Core
    ../Core/Src/: gpio.c iwdg.c main.c rtc.c stm32f1xx_hal_msp.c stm32f1xx_it.c timing.c usart.c usb.c
  group Application/User/includes
    ../Core/Inc/: gpio.h iwdg.h main.h rtc.h stm32_assert.h stm32_tm1637.h stm32f1xx_hal_conf.h stm32f1xx_it.h usart.h usb.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
